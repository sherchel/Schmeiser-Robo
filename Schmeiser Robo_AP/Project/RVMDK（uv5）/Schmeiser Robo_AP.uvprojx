# Keil uVision project Schmeiser Robo_AP.uvprojx, settings and files
target Schmeiser Robo_AP (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Schmeiser Robo_AP +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\FWlib\inc;..\..\Libraries\CMSIS;..\..\User;..\..\User\AP_Test;..\..\User\ESP8266;..\..\User\GeneralTim;..\..\User\Motor;..\..\User\SYS_BASE\Common;..\..\User\SYS_BASE\gpio;..\..\User\SYS_BASE\led;..\..\User\SYS_BASE\delay;..\..\User\SYS_BASE\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group DOC
    ../../User/: CodeDesignRecord.txt
  group STARUP
    ../../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group Libraries
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../../User/: stm32f10x_it.c main.c
    ../../User/SYS_BASE/Common/: Common.c
    ../../User/ESP8266/: bsp_esp8266.c
    ../../User/GeneralTim/: bsp_GeneralTim.c
    ../../User/Motor/: bsp_motor.c
    ../../User/SYS_BASE/gpio/: bsp_gpio.c
    ../../User/SYS_BASE/led/: bsp_led.c
    ../../User/SYS_BASE/usart/: bsp_usart1.c
    ../../User/SYS_BASE/delay/: delay.c
    ../../User/AP_Test/: AP_test.c
